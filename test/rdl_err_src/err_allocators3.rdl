
reg foo {
    field {} f1 %= 0;
};
